require core-image-renesas-minimal.inc
